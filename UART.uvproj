# Keil uVision project UART.uvproj, settings and files
target RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UART
  c flags: Optim=1
  c include: ..\common\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ../common/src/: startup_LPC17xx.s
  group System Code
    ../common/src/: system_LPC17xx.c
  group Source Code
    ./: uart.c main_circles2.c joystick.c CRIS_UTILS.c CRIS_UTILS.h GLCD.h joystick.h
    ../../../../Lab 3/Lab3_files_f13/lab3_circle1_f13/: GLCD_LPC1700.c
  group Documentation
    ./: Abstract.txt
target FLASH (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UART +hex
  c flags: Optim=1
  c include: ..\common\inc
  asm include: ..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
